Commit message: added visible obstacle

File: gym_pybullet_drones/assets/sphere.urdf (robot description, URDF)
Before this commit: robot sphere, 1 links, 0 joints
Links:
- link base_link: geometry collision sphere radius=0.15; visual sphere radius=0.15
